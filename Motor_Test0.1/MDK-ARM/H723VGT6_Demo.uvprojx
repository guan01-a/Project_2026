# Keil uVision project H723VGT6_Demo.uvprojx, settings and files
target H723VGT6_Demo (6190000::V6.19::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: H723VGT6_Demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../User_chariot/Chassis;../User_ita;../User_tsk;.cmsis/include;RTE/_H723VGT6_Demo;../User_chariot;../User_chariot/KFS;../User_alg;../User_dvc;../User_mid;..\User_drv
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group User_chariot
    ../User_chariot/: crt_lift.cpp crt_weapon_head.cpp crt_chassis.cpp
  group User_tsk
    ../User_tsk/: tsk_config_and_callback.cpp
  group User_ita
    ../User_ita/: ita_robot.cpp ita_robot.h
  group User_dvc
    ../User_dvc/: dvc_motor_mksesc.cpp dvc_motor_dji.cpp dvc_motor_dji.h dvc_pmt45.cpp dvc_pmt45.h dvc_dr16.cpp dvc_dr16.h dvc_dwt.cpp dvc_dwt.h dvc_motor_dm.cpp dvc_motor_dm.h Robstride.h Robstride01.cpp dvc_motor_rs.cpp dvc_motor_rs.h dvc_airtool.cpp dvc_fsI6x.cpp dvc_fsI6x.h dvc_brtencoder.cpp dvc_brtencoder.h dvc_motor_mksesc.h dvc_motor_rmd.cpp dvc_motor_rmd.h dvc_motor_ul.cpp dvc_motor_ul.h
  group User_drv
    ../User_drv/: drv_tim.cpp drv_math.cpp drv_gpio_exti.cpp drv_gpio_exti.h drv_uart.h drv_exti.h drv_bsp.cpp drv_can.cpp drv_uart.cpp motor_control.h ris_protocol.h crc_ccitt.h drv_motor_ul_M8010.cpp
  group User_alg
    ../User_alg/: alg_pid.cpp alg_pid.h alg_slope.cpp alg_slope.h alg_fsm.cpp alg_fsm.h
  group MIddleware
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfsp_math.lib
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fdcan.c memorymap.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group User_mid
    ../User_mid/: mid_ibus.cpp mid_ibus.h
software components: CMSIS:CORE 5.6.0
